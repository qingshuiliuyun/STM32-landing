# Keil uVision project SysTick.uvproj, settings and files
target SysTick (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SysTick +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4
  c include: ..\;..\user;..\..\SysTick;..\landing;..\user\inc;..\user\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c SysTick.lib
  group MDK-ARM
    ./: startup_stm32f40xx.s
  group landing
    ../landing/: landing.c FK_langding.c
